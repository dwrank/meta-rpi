SUMMARY = "RPi integration image"
DESCRIPTION = "RPi core image + serial port access + ssh access"

inherit rpi-core-access

export IMAGE_BASENAME = "rpi-int"
