SUMMARY = "RPi production image"
DESCRIPTION = "RPi core image"

inherit rpi-core

export IMAGE_BASENAME = "rpi-prod"
