
LINUX_VERSION = "4.14.58"

SRCREV = "a06f9e522301dfacc1f382d72e6a9792d8350328"

PV = "${LINUX_VERSION}+git${SRCPV}"
