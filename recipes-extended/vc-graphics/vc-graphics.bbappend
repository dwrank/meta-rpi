
include ../common/firmware_append.inc

