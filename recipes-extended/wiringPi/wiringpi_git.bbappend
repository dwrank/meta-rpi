# v2.46 for Pi v3+
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRCREV = "8d188fa0e00bb8c6ff6eddd07bf92857e9bd533a"

SRC_URI = "git://git.drogon.net/wiringPi \
           file://0001-Add-initial-cross-compile-support-v2.46.patch \
           "
